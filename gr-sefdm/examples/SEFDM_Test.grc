<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SEFDM_Test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrier_freq</value></param>
<param><key>value</key><value>450e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_point_on_graph</value></param>
<param><key>value</key><value>29500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>320 + 80 * 20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len_with_margin_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/ivan/Documents/Diplom/Signals/RxBaseband_Truncate_ComlexFloat32_bin/rx_tr_randi_20ofdm_20000pckt_15.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len_with_margin_tag_key</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[-0.0690, -0.2497, 0.6374, -0.2497, -0.0690]</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>40</value></param>
<param><key>freq0</key><value>carrier_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>32</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>hackrf=2359524b</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_file_message_sink</key>
<param><key>id</key><value>pyqt_file_message_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filetype</key><value>"complex64"</value></param>
<param><key>filename</key><value>/dev/null</value></param>
<param><key>label</key><value>Save Segment</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>update_time</key><value>0.00010</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>num_point_on_graph</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>num_point_on_graph</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>sefdm_extract_packets_from_stream</key>
<param><key>id</key><value>sefdm_extract_packets_from_stream_0</value></param>
<param><key>TagKey</key><value>packet_len_with_margin_tag_key</value></param>
</block>
<block>
<key>sefdm_ieee_802_11a_coarse_time_synch</key>
<param><key>id</key><value>sefdm_ieee_802_11a_coarse_time_synch_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>sefdm_ieee_802_11a_preamble_detection</key>
<param><key>id</key><value>sefdm_ieee_802_11a_preamble_detection_0</value></param>
<param><key>Thr</key><value>0.3</value></param>
<param><key>Eps</key><value>-20</value></param>
<param><key>PacketLen</key><value>packet_len</value></param>
<param><key>Margin</key><value>150</value></param>
<param><key>TagKey</key><value>packet_len_with_margin_tag_key</value></param>
<param><key>D</key><value>16</value></param>
<param><key>L</key><value>144</value></param>
<param><key>Algrthm</key><value>True</value></param>
</block>
<block>
<key>sefdm_ieee_802_11a_synchronization</key>
<param><key>id</key><value>sefdm_ieee_802_11a_synchronization_0</value></param>
<param><key>CTS_segmentLen</key><value>160</value></param>
<param><key>FFS_isMake</key><value>True</value></param>
<param><key>FFS_offset</key><value>15</value></param>
<param><key>FTS_segmentLen</key><value>40</value></param>
<param><key>FTS_etalonLen</key><value>32</value></param>
<param><key>FTS_offset</key><value>160 + 32 - 20</value></param>
<param><key>Payload_GILen</key><value>16</value></param>
<param><key>Payload_subcarrNum</key><value>64</value></param>
<param><key>Payload_symNum</key><value>20</value></param>
</block>
<block>
<key>sefdm_ofdm_symbol_demodulation</key>
<param><key>id</key><value>sefdm_ofdm_symbol_demodulation_0</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_coarse_time_synch_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_synchronization_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_preamble_detection_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_preamble_detection_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_preamble_detection_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_extract_packets_from_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_coarse_time_synch_0</source_block_id><sink_block_id>sefdm_ofdm_symbol_demodulation_0</sink_block_id><source_key>out</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_preamble_detection_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_preamble_detection_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_preamble_detection_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_preamble_detection_0</source_block_id><sink_block_id>sefdm_extract_packets_from_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_synchronization_0</source_block_id><sink_block_id>sefdm_ofdm_symbol_demodulation_0</sink_block_id><source_key>out</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>sefdm_ofdm_symbol_demodulation_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out2</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>sefdm_ofdm_symbol_demodulation_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>out2</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sefdm_ofdm_symbol_demodulation_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out2</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>sefdm_ofdm_symbol_demodulation_0</source_block_id><sink_block_id>pyqt_const_plot_1</sink_block_id><source_key>out2</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>sefdm_ofdm_symbol_demodulation_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>out2</source_key><sink_key>in</sink_key></connection>
</flow_graph>
