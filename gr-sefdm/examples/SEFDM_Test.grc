<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SEFDM_Test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdr_len_cp</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdr_n_sym</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_gi_len</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_subcarr_num</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_sym_num</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pld_len_cp</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pld_n_sym</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prmbl_hdr_no_payload_len</value></param>
<param><key>value</key><value>320 + hdr_n_sym * (sym_fft_size + hdr_len_cp) + (sym_fft_size + hdr_len_cp) + pld_n_sym * (sym_sefdm_len+ pld_len_cp)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prmbl_payload_len</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>320 + payload_sym_num * (payload_subcarr_num + payload_gi_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qtTimeSink_num_point</value></param>
<param><key>value</key><value>29500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_carrier_freq</value></param>
<param><key>value</key><value>2290e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_fft_size</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_len_left_gi</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_len_right_gi</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_n_inf</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_sefdm_len</value></param>
<param><key>value</key><value>26</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ivan/Documents/Diplom/file.test</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/ivan/Documents/Signals/1_rx_sefdm_11.05.18/rx_sefdm__pckt_10000_1000__hdr_6_6__pld_20_6__sym_32_26_20_3_2_bpsk__.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[-0.0690, -0.2497, 0.6374, -0.2497, -0.0690]</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>mapper_demapper</key>
<param><key>id</key><value>mapper_demapper_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modtype</key><value>mapper.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>38</value></param>
<param><key>freq0</key><value>radio_carrier_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>40</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>hackrf=2359524b</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>radio_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>update_time</key><value>0.00010</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.00010</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>update_time</key><value>0.00010</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>qtTimeSink_num_point</value></param>
<param><key>srate</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>qtTimeSink_num_point</value></param>
<param><key>srate</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>sefdm_extract_packets_from_stream</key>
<param><key>id</key><value>sefdm_extract_packets_from_stream_0</value></param>
<param><key>TagKey</key><value>"packet_len"</value></param>
</block>
<block>
<key>sefdm_header_synchronization</key>
<param><key>id</key><value>sefdm_header_synchronization_0</value></param>
<param><key>HdrNoPldLen</key><value>prmbl_hdr_no_payload_len - 320</value></param>
<param><key>Hdr_LenCp</key><value>hdr_len_cp</value></param>
<param><key>Hdr_Nsym</key><value>hdr_n_sym</value></param>
<param><key>Pld_LenCp</key><value>pld_len_cp</value></param>
<param><key>Pld_Nsym</key><value>pld_n_sym</value></param>
<param><key>Sym_FftSize</key><value>sym_fft_size</value></param>
<param><key>Sym_LeftGILen</key><value>sym_len_left_gi</value></param>
<param><key>Sym_RightGiLen</key><value>sym_len_right_gi</value></param>
<param><key>Sym_SefdmLen</key><value>sym_sefdm_len</value></param>
</block>
<block>
<key>sefdm_id_detector</key>
<param><key>id</key><value>sefdm_id_detector_0</value></param>
<param><key>N_iteration</key><value>3</value></param>
<param><key>Pld_Nsym</key><value>pld_n_sym</value></param>
<param><key>Sym_FftSize</key><value>sym_fft_size</value></param>
<param><key>Sym_LeftGILen</key><value>sym_len_left_gi</value></param>
<param><key>Sym_RightGiLen</key><value>sym_len_right_gi</value></param>
<param><key>Sym_SefdmLen</key><value>sym_sefdm_len</value></param>
</block>
<block>
<key>sefdm_ieee_802_11a_ofdm_symbol_demodulation</key>
<param><key>id</key><value>sefdm_ieee_802_11a_ofdm_symbol_demodulation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>subcarrNum</key><value>payload_subcarr_num</value></param>
<param><key>symNum</key><value>payload_sym_num</value></param>
</block>
<block>
<key>sefdm_ieee_802_11a_preamble_detection</key>
<param><key>id</key><value>sefdm_ieee_802_11a_preamble_detection_0</value></param>
<param><key>ThrCntrMax</key><value>60</value></param>
<param><key>Thr</key><value>0.6</value></param>
<param><key>Eps</key><value>-20</value></param>
<param><key>PacketLen</key><value>prmbl_hdr_no_payload_len</value></param>
<param><key>Margin</key><value>150</value></param>
<param><key>TagKey</key><value>"packet_len"</value></param>
<param><key>D</key><value>16</value></param>
<param><key>L</key><value>144</value></param>
</block>
<block>
<key>sefdm_ieee_802_11a_synchronization</key>
<param><key>id</key><value>sefdm_ieee_802_11a_synchronization_0</value></param>
<param><key>CTS_segmentLen</key><value>160</value></param>
<param><key>ChannelEst_isMake</key><value>False</value></param>
<param><key>FFS_isMake</key><value>True</value></param>
<param><key>FFS_offset</key><value>15</value></param>
<param><key>FTS_segmentLen</key><value>40</value></param>
<param><key>FTS_etalonLen</key><value>32</value></param>
<param><key>FTS_offset</key><value>160 + 32 - 20</value></param>
<param><key>PacketLen</key><value>prmbl_hdr_no_payload_len</value></param>
</block>
<block>
<key>sefdm_mf_demodulator</key>
<param><key>id</key><value>sefdm_mf_demodulator_0</value></param>
<param><key>ChannelCompensation_isMake</key><value>True</value></param>
<param><key>PhaseOffsetCompensation_isMake</key><value>True</value></param>
<param><key>Pld_Nsym</key><value>pld_n_sym</value></param>
<param><key>Sym_FftSize</key><value>sym_fft_size</value></param>
<param><key>Sym_LeftGILen</key><value>sym_len_left_gi</value></param>
<param><key>Sym_RightGiLen</key><value>sym_len_right_gi</value></param>
<param><key>Sym_SefdmLen</key><value>sym_sefdm_len</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>mapper_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_synchronization_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_preamble_detection_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_preamble_detection_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mapper_demapper_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_preamble_detection_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_extract_packets_from_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_header_synchronization_0</source_block_id><sink_block_id>sefdm_mf_demodulator_0</sink_block_id><source_key>sefdm_hdr_synch_out</source_key><sink_key>mf_demodulator_in</sink_key></connection>
<connection><source_block_id>sefdm_id_detector_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1</sink_block_id><source_key>id_detector_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_ofdm_symbol_demodulation_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out2</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_preamble_detection_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_preamble_detection_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_preamble_detection_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_preamble_detection_0</source_block_id><sink_block_id>sefdm_extract_packets_from_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_synchronization_0</source_block_id><sink_block_id>sefdm_header_synchronization_0</sink_block_id><source_key>out</source_key><sink_key>sefdm_hdr_synch_in</sink_key></connection>
<connection><source_block_id>sefdm_ieee_802_11a_synchronization_0</source_block_id><sink_block_id>sefdm_ieee_802_11a_ofdm_symbol_demodulation_0</sink_block_id><source_key>out</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>sefdm_mf_demodulator_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>mf_demodulator_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sefdm_mf_demodulator_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>mf_demodulator_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sefdm_mf_demodulator_0</source_block_id><sink_block_id>sefdm_id_detector_0</sink_block_id><source_key>mf_demodulator_out</source_key><sink_key>id_detector_in</sink_key></connection>
</flow_graph>
