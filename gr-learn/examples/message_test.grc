<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>message_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.init_c32vector(5, (1, 2, 3, 1j, 11))</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.from_bool(True)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>learn_message_test</key>
<param><key>id</key><value>learn_message_test_0</value></param>
</block>
<block>
<key>pyqt_file_message_souce</key>
<param><key>id</key><value>pyqt_file_message_souce_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filetype</key><value>"complex64"</value></param>
<param><key>filename</key><value>/tmp/data.dat</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>learn_message_test_0</sink_block_id><source_key>strobe</source_key><sink_key>in_port_name_ID</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>learn_message_test_0</sink_block_id><source_key>strobe</source_key><sink_key>in_port_name_ID</sink_key></connection>
<connection><source_block_id>learn_message_test_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out_port_name_ID</source_key><sink_key>print</sink_key></connection>
</flow_graph>
